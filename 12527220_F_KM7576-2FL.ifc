Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-02-20T10:25:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 20 10:25:23 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\ca8c1f2c-9901-4390-8e33-b9644a3a5d49\4793bc3c-7172-4010-8362-984416938531\ifc * Database version: 5507 * Database creation date: Tue Feb 20 10:25:23 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 20 10:25:23 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 20 10:25:23 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12527220_F_KM7576-2FL:26757673_F_12527220_KM7576-2FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26757673_F_12527220_KM7576-2FL
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26757673_F_12527220_KM7576-2FL
Material: z_Miele_Design_CLST, z_Miele_Design_Stainless Steel, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 5.2 mm; Height: 371 mm; Depth: 5.2 mm
